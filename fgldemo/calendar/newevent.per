# Property of Four Js*
# (c) Copyright Four Js 2017, 2017. All Rights Reserved.
# * Trademark of Four Js Development Tools Europe Ltd
#   in the United States and elsewhere
# 
# Four Js and its suppliers do not warrant or guarantee that these
# samples are accurate and suitable for your purposes. Their inclusion is
# purely for information purposes only.

LAYOUT(TEXT="Event")
VBOX
GROUP --(TEXT="Title")
GRID
{
  Title[title        ]
}
END --GRID
END --GROUP

GROUP
GRID
{
 [allday           ]
  Starts [startDate]
  Ends   [endDate  ]
  Repeat [freq     ]
}
END
END

GROUP (TEXT="Alerts")
GRID
{
  Alert        [first  ]
  Second Alert [second ]
}
END
END

GROUP
GRID
{
  URL [url        ]
  Notes
 [notes           ]
 [                ]
 [                ]
}
END

END
END
ATTRIBUTES
EDIT title=FORMONLY.TITLE,COMMENT="<Enter Title>",JUSTIFY=LEFT;
CHECKBOX allday=FORMONLY.allday,TITLE="All-day";
DATETIMEEDIT startDate=FORMONLY.startDate,TITLE="Starts",NOT NULL;
DATETIMEEDIT endDate=FORMONLY.endDate,TITLE="Ends",NOT NULL;
COMBOBOX freq=FORMONLY.freq,TITLE="Repeat",ITEMS=((NULL,"Never"),
                                 ("daily","Every Day"),
                                 ("weekly","Every Week"),
                                 ("monthly","Every Month"),
                                 ("yearly","Every Year"));

COMBOBOX first=FORMONLY.firstReminderMinutes,TITLE="Alert",ITEMS=((NULL,"None"),
                                             (15,"15 min before"),
                                             (60,"1 hour before"),
                                             (1440,"1 day before"),
                                             (10080,"1 week before"),
                                             (46080,"1 month before"));
COMBOBOX second=FORMONLY.secondReminderMinutes,TITLE="Second Alert",ITEMS=((NULL,"None"),
                                             (15,"15 min before"),
                                             (60,"1 hour before"),
                                             (1440,"1 day before"),
                                             (10080,"1 week before"),
                                             (46080,"1 month before"));

EDIT url=FORMONLY.url,COMMENT="<Url>",JUSTIFY=LEFT;
TEXTEDIT notes=FORMONLY.notes,COMMENT="<Notes>";
